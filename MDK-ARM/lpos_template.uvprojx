# Keil uVision project lpos_template.uvprojx, settings and files
target lpos_template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476VETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lpos_template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L476xx,USE_HAL_DRIVER,STM32L476xx
  c include: ../Core/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
    ./: FillSystemStack.s
  group Application/User/Core
    ../Core/Src/: main.c tickless.c freertos.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_iwdg.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_lptim.c stm32l4xx_hal_lcd.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group System
    ../Core/Src/: sys_lib.c sys_isr.c sys_list.c boot.c
  group Libraries
    ../Libraries/lib_leds/: lib_leds.c
    ../Libraries/lib_buzzer/: lib_buzzer.c
    ../Libraries/lib_buttons/: lib_buttons.c
    ../Libraries/lib_glasslcd/: lib_glasslcd.c
  group Hardware
    ../Libraries/lib_leds/: hw_leds.c
    ../Libraries/lib_buzzer/: hw_buzzer.c
    ../Libraries/lib_buttons/: hw_buttons.c
    ../Libraries/lib_glasslcd/: hw_glasslcd.c
  group Board
    ../Core/Inc/: pin_defines.h
software components: CMSIS:CORE 5.0.2
